# IAR project MainCPU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; FSL_RTOS_FREE_RTOS; SDK_DEBUGCONSOLE_UART
  ICCARM.CCDiagSuppress: Pa082,Pe191,Pe177
  ICCARM.CCIncludePath2: Startup; ../SDK/devices/LPC55S69; ..\SDK\rtos\amazon-freertos\freertos_kernel\include; ..\SDK\rtos\amazon-freertos\freertos_kernel\include\Private; ..\SDK\rtos\amazon-freertos\freertos_kernel\portable\ARMv8M\non_secure\portable\IAR\ARM_CM33_NTZ; ..\SDK\devices\LPC55S69\drivers; ..\SDK\CMSIS\Include; ..\Device; ..\M3MForth; ..\Infrastructure; ..\Common\Lang
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Startup; ../SDK/devices/LPC55S69; ..\SDK\rtos\amazon-freertos\lib\include; ..\SDK\rtos\amazon-freertos\lib\include\Private; ..\SDK\rtos\amazon-freertos\lib\FreeRTOS\portable\IAR\ARM_CM33_NTZ\non_secure; ..\SDK\devices\LPC55S69\drivers; ..\SDK\CMSIS\Include; ..\Device; ..\SDK\devices\LPC55S69\utilities; ..\SDK\devices\LPC55S69\utilities\str; ..\SDK\devices\LPC55S69\utilities\debug_console; ..\SDK\components\serial_manager; ..\SDK\components\uart; AppConfig; AppConfig\Systemconfig; ..\M3MForth; ..\Infrastructure; ..\Infrastructure\MemoryManager; ..\Infrastructure\InterProcessMessage; ..\Common; ..\Common\Lang; ..\Common\Utilities; ..\Common\DB; ..\Database; Application; ..\MetaDrivers; ..\SDK\middleware\sdmmc; ..\SDK\middleware\sdmmc\inc; ..\SDK\middleware\sdmmc\port; ..\SDK\middleware\sdmmc\src
  OBJCOPY.OOCOutputFile: MainCPU.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: __stack_size__=0x800; __heap_size__=0x2000
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkAdditionalLibs: ../SDK/devices/LPC55S69/iar/iar_lib_power_cm33_core0.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group Application/Startup
    Startup/: board.c clock_config.c pin_mux.c
    ../SDK/devices/LPC55S69/iar/: startup_LPC55S69_cm33_core0.s
  group CPU
    ../SDK/devices/LPC55S69/: system_LPC55S69_cm33_core0.c
  group Device
    ../Device/: usart.c USART0.c
  group FSL_Device
    ../SDK/devices/LPC55S69/drivers/: fsl_clock.c fsl_common.c fsl_flexcomm.c fsl_gpio.c fsl_inputmux.c fsl_power.c fsl_reset.c fsl_usart.c fsl_usart_freertos.c
  group Infrastructure
    ../Infrastructure/: conio.c snprintf99.c
  group mForth
    ../M3MForth/: asswords.c corewords.c float.c forth.c words.c
  group RTOS
    ../SDK/rtos/amazon-freertos/freertos_kernel/portable/MemMang/: heap_2.c
    ../SDK/rtos/amazon-freertos/freertos_kernel/: list.c queue.c tasks.c timers.c
    ../SDK/rtos/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
